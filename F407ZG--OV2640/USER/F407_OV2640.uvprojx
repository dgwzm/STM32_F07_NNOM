# Keil uVision project F407_OV2640.uvprojx, settings and files
target OV2640 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: F407_OV2640 +hex
  c flags: Optim=4 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\HARDWARE\LCD;..\HARDWARE\KEY;..\HARDWARE\DCMI;..\HARDWARE\OV2640;..\HARDWARE\TIMER;..\HARDWARE\USART2;..\FWLIB\inc;..\USMART;..\nnom_inc;..\nnom_inc\layers;..\mobilenet;..\mobilenet\data
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/DCMI/: dcmi.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/OV2640/: ov2640.c sccb.c
    ../HARDWARE/TIMER/: timer.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_dcmi.c stm32f4xx_gpio.c stm32f4xx_fsmc.c stm32f4xx_dma.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_tim.c
  group nnom
    ../nnom_src/backends/: nnom_local.c nnom_local_q15.c
    ../nnom_src/core/: nnom.c nnom_layers.c nnom_tensor.c nnom_utils.c
    ../nnom_src/layers/: nnom_activation.c nnom_avgpool.c nnom_baselayer.c nnom_concat.c nnom_conv2d.c nnom_conv2d_trans.c nnom_cropping.c nnom_dense.c nnom_dw_conv2d.c nnom_flatten.c nnom_global_pool.c nnom_gru_cell.c nnom_input.c nnom_lambda.c nnom_lstm_cell.c nnom_matrix.c nnom_maxpool.c nnom_output.c nnom_reshape.c nnom_rnn.c nnom_simple_cell.c nnom_softmax.c nnom_sumpool.c nnom_upsample.c nnom_zero_padding.c
  group mobilenet
    ../mobilenet/: mobilenet_test.c q_activation_layer.c q_conv_layer.c q_inv_residual_layer_1.c q_inv_residual_layer_2.c q_inv_residual_layer_3.c q_linear_layer.c q_pool_layer.c
software components: CMSIS:CORE 5.4.0
